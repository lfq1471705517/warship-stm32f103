# Keil uVision project leds.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: leds +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\STM32F10x_StdPeriph_Lib_V3.6.0\inc;.\platform;.\drivers;.\FreeRTOSv202112.00\include;.\FreeRTOSv202112.00\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group apps
    ./apps/: main.c
  group drivers
    ./drivers/: delay.c delay.h led.c led.h sys.c sys.h timer.c timer.h usart.c usart.h
  group platform
    ./platform/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group STM32F10x_StdPeriph_Lib_V3.6.0
    ./STM32F10x_StdPeriph_Lib_V3.6.0/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./STM32F10x_StdPeriph_Lib_V3.6.0/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group FreeRTOSv202112.00
    ./FreeRTOSv202112.00/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOSv202112.00/portable/MemMang/: heap_4.c
    ./FreeRTOSv202112.00/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ./FreeRTOSv202112.00/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
